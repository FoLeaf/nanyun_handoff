# IAR project GenericApp.ewp, settings and files
configuration CoordinatorDongle (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; ZCL_REPORT_DESTINATION_DEVICE; APP_TARGET_COORDINATOR_DONGLE; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; \..\\Source; ..\Source; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Projects\\zstack\\ZMain\TI2530DB; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\hal\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\hal\target\CC2530EB; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\high_level; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\low_level\srf04; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\low_level\srf04\single_chip; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mt; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\osal\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\services\saddr; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\services\sdata; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\af; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\bdb; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\gp; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\nwk; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sapi; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sec; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sys; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\zcl; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\zdo; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\zmac; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Projects\\zstack\\Tools\CC2530DB\f8w2530.xcl
configuration CoordinatorNormal (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; ZCL_REPORT_DESTINATION_DEVICE; APP_TARGET_COORDINATOR_NORMAL; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
configuration RouterNormal (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; BDB_REPORTING; APP_TARGET_ROUTER_NORMAL; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
  ICC8051.CCIncludePath2: $PROJ_DIR$; \..\\Source; ..\Source; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Projects\\zstack\\ZMain\TI2530DB; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\hal\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\hal\target\CC2530EB; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\high_level; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\low_level\srf04; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mac\low_level\srf04\single_chip; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\mt; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\osal\include; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\services\saddr; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\services\sdata; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\af; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\bdb; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\nwk; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\bdb; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\gp; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sapi; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sec; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\sys; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\zcl; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\stack\zdo; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\zmac; D:\\Develop\\Texas Instruments\\Z-Stack 3.0.2\\Components\zmac\f8w
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
  group App
    /..//Source/: aht30.c aht30.h aht30_port.c aht30_port.h app_config.h app_display.c app_display.h app_led.c app_led.h myiic.c myiic.h oled.c oled.h oledFont.c oledFont.h OSAL_GenericApp.c zcl_genericapp.c zcl_genericapp.h zcl_genericapp_data.c
  group BDB
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/GP/: cGP_stub.h dGP_stub.h gp_common.c gp_common.h gp_interface.h gp_proxyTbl.c
  group HAL/Common
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/ZLIGHT/Config
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530PMP4712/: hal_board_cfg.h
  group HAL/Target/ZLIGHT/Drivers
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530PMP4712/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/ZLIGHT/Include
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/hal/target/CC2530PMP4712/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/af/: AF.c AF.h
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h
    ../Source/: zcl_ha.c zcl_ha.h
  group Security
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/services/saddr/: saddr.c saddr.h
  group Tools
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Projects//zstack//Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Components/zmac/: ZMAC.h
  group ZMain
    D://Develop//Texas Instruments//Z-Stack 3.0.2//Projects//zstack//ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
