# Keil uVision project SX126xSTM32F103C8Demo.uvprojx, settings and files
target SX126xSTM32F103C8Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SX126xSTM32F103C8Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HAL\delay;..\HAL;..\peripherals\radio;..\peripherals\radio\sx126x;..\peripherals\radio\sx126x_example\sx126x_send;..\peripherals\radio\sx126x_example\sx126x_recive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c
  group HAL
    ../HAL/delay/: delay.c
    ../HAL/: HAL_uart.c SX126xSTM32F103-board.c HAL_SPI.c
  group SX126xRadio
    ../peripherals/radio/sx126x/: radio.c sx126x.c
  group SX126xExample
    ../peripherals/radio/sx126x_example/sx126x_send/: sx126x_example_send.c
    ../peripherals/radio/sx126x_example/sx126x_recive/: sx126x_example_recive.c
